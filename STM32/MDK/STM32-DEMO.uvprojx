# Keil uVision project STM32-DEMO.uvprojx, settings and files
target LED-DEMO (ARM-ADS)
  device: STM32F103VE STMicroelectronics
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: STM32-DEMO +hex
  c flags: OneElfS=1
  c define: USE_STDPERIPH_DRIVER  STM32F10X_HD
  c include: ..\CMSIS;..\USER;..\APP;..\BSP;..\uCOS-II\Ports;..\uCOS-II\Source;..\Driverlib\inc;..\UCGUI\Core;..\UCGUI\Widget;..\UCGUI\WM;..\UCGUI\Config_Other;..\GUIDemo;..\UCGUI\Config;..\OSC
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group startup
    ../CMSIS/startup/: startup_stm32f10x_hd.s
  group USER
    ../USER/: main.c stm32f10x_it.c
  group DriverLib
    ../Driverlib/src/: misc.c stm32f10x_dac.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_sdio.c stm32f10x_usart.c stm32f10x_dma.c
  group CMSIS
    ../CMSIS/: core_cm3.c system_stm32f10x.c
  group BSP
    ../BSP/: BSP.c dac.c delay.c usart.c mylcd.c Normal.c sdcard.c
  group APP
    ../APP/: app.c os_cfg.h WindowDLG.c FramewinDLG.c WindowDLGDwon.c
  group uCOS-II\Source
    ../uCOS-II/Source/: os_core.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c
  group uCOS-II\Ports
    ../uCOS-II/Ports/: os_cpu_a.asm os_cpu_c.c os_dbg.c os_cpu.h
  group UCGUI
    ../UCGUI/Config/: GUI_X_uCOS.c GUI_X.c GUI_X_Touch.c
    ../UCGUI/LCDDriver/: LCDDummy.c
    ../UCGUI/: STM32-DEMO.lib
  group OSC
    ../OSC/: OSC.c
